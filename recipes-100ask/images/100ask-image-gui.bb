DESCRIPTION = "Freescale Image"
LICENSE = "MIT"

#require recipes-fsl/images/fsl-image-validation-imx.bb
require recipes-100ask/images/100ask-image-validation-imx.bb
